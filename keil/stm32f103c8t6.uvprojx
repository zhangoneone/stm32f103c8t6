# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target stm32f103c8t6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6 +hex
  c flags: Optim=4 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group boot
    ../boot/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group algorithm
    ../algorithm/: ns_bitree.c ns_list.c ns_queue.c ns_stack.c ns_hashtable.c ns_fsm.c
  group stdriver
    ../stdriver/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_it.c stm32f10x_it.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group bsp
    ../bsp/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h user_usart.c user_led.c user_pwr.c user_crc.c user_rcc.c user_i2c.c user_spi.c user_timer.c user_flash.c user_exti.c user_dma.c user_watchdog.c user_fsmc.c
  group os
    ../os/core/: croutine.c event_groups.c heap_4.c list.c main.c port.c queue.c stream_buffer.c tasks.c timers.c user_app_config.c
  group fs
    ../os/fs/fat/: ff.c diskio.c ffsystem.c ffunicode.c
  group net
    ../net/arch/: sys_arch.c
    ../net/netif/: ethernet.c
    ../net/core/: sys.c netif.c init.c altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c ip.c mem.c memp.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../net/api/: tcpip.c api_msg.c api_lib.c netbuf.c
    ../net/core/ipv4/: etharp.c autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group device
    ../device/: ns_it_manage.c ns_dma_manage.c ns_iochannel_manage.c ns_driver.c ns_device.c ns_bus.c ns_posix_interface.c ns_test.c ns_eeprom.c ns_w25qxx.c ns_dm9000.c
  group io
    ../os/io/: xprintf.c ansi.c ansi_port.c nr_micro_shell.c nr_micro_shell_commands.c
  group app
    ../app/: user_led_control.c user_usart_control.c user_pwr_control.c user_crc_control.c user_rcc_control.c user_app_common.h user_flash_control.c user_fs_control.c user_io_control.c user_shell_control.c user_exti_control.c user_timer_control.c user_device_control.c user_cplus_control.cpp user_tcpip_control.c
target stm32f103zet6 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6 +hex
  c flags: Optim=4 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
